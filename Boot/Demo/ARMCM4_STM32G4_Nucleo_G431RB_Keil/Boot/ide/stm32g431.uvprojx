# Keil uVision project stm32g431.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: openblt_stm32g431
  AfterMake: fromelf --m32 --output=..\bin\openblt_stm32g431.srec ..\bin\openblt_stm32g431.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G431xx
  c misc: --diag_suppress=111
  c include: ..\..\Boot;..\lib;..\lib\CMSIS\Device\ST\STM32G4xx\Include;..\lib\CMSIS\Include;..\lib\STM32G4xx_HAL_Driver\Inc;..\..\..\..\Source;..\..\..\..\Source\ARMCM4_STM32G4;..\..\..\..\Source\ARMCM4_STM32G4\Keil
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: ..\stm32g431.sct
  group App
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32g431xx.s
  group Lib
    ../lib/: stm32g4xx_hal_conf.h system_stm32g4xx.c
    ../lib/CMSIS/Device/ST/STM32G4xx/Include/: stm32g4xx.h stm32g431xx.h system_stm32g4xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm4.h tz_context.h
    ../lib/STM32G4xx_HAL_Driver/Inc/: stm32g4xx_hal.h stm32g4xx_hal_cortex.h stm32g4xx_hal_def.h stm32g4xx_hal_dma.h stm32g4xx_hal_dma_ex.h stm32g4xx_hal_exti.h stm32g4xx_hal_fdcan.h stm32g4xx_hal_flash.h stm32g4xx_hal_flash_ex.h stm32g4xx_hal_flash_ramfunc.h stm32g4xx_hal_gpio.h stm32g4xx_hal_gpio_ex.h stm32g4xx_hal_pwr.h stm32g4xx_hal_pwr_ex.h stm32g4xx_hal_rcc.h stm32g4xx_hal_rcc_ex.h stm32g4xx_hal_tim.h stm32g4xx_hal_tim_ex.h stm32g4xx_ll_bus.h stm32g4xx_ll_cortex.h stm32g4xx_ll_crs.h stm32g4xx_ll_dma.h stm32g4xx_ll_dmamux.h stm32g4xx_ll_exti.h stm32g4xx_ll_gpio.h stm32g4xx_ll_pwr.h stm32g4xx_ll_rcc.h stm32g4xx_ll_system.h stm32g4xx_ll_usart.h stm32g4xx_ll_utils.h
    ../lib/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_dma.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_rcc.c stm32g4xx_ll_usart.c stm32g4xx_ll_utils.c
  group Core
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h mb.c mb.h
    ../../../../Source/ARMCM4_STM32G4/: can.c cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h mbrtu.c
    ../../../../Source/ARMCM4_STM32G4/Keil/: cpu_comp.c
software components: CMSIS:CORE 4.3.0
