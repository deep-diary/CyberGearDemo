# Keil uVision project CyberGearDemo.uvprojx, settings and files
target CyberGearDemo (6210000::V6.21::ARMCLANG)
  device: STM32G431VBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: CyberGearDemo +hex
  AfterMake: fromelf.exe --m32combined --output "$L@L.srec" "#L"
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM4,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G431xx
  c include: ../Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../MCSDK_v6.4.0-Full/MotorControl/MCSDK/MCLib/G4xx/Inc;../MCSDK_v6.4.0-Full/MotorControl/MCSDK/MCLib/Any/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;..\CANCommunication;..\plugins;..\PreferenceWriter;..\user_application;..\user_application\applications;..\user_application\interface;..\Middlewares\ST\EEPROM_Emul\Core;..\Middlewares\ST\EEPROM_Emul\Porting\STM32G4
  memory RVCT4: ROM 0x8000000 size 0x16000
  memory RVCT9: RAM 0x20001000 size 0x7000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c motorcontrol.c speed_torq_ctrl.c pwm_common.c mc_api.c mc_config.c mc_config_common.c mcp_config.c mc_tasks.c mc_tasks_foc.c pwm_curr_fdbk.c regular_conversion_manager.c mc_math.c mc_interface.c stm32_mc_common_it.c stm32g4xx_mc_it.c mc_parameters.c hf_registers.c sync_registers.c mcp.c usart_aspep_driver.c mc_configuration_registers.c aspep.c mc_app_hooks.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_ll_cordic.c stm32g4xx_hal_fdcan.c stm32g4xx_ll_i2c.c stm32g4xx_ll_opamp.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_usart.c stm32g4xx_ll_rcc.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Middlewares/MotorControl
    ../MCSDK_v6.4.0-Full/MotorControl/MCSDK/MCLib/G4xx/Src/: stspin32g4.c r3_2_g4xx_pwm_curr_fdbk.c
    ../MCSDK_v6.4.0-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c enc_align_ctrl.c encoder_speed_pos_fdbk.c trajectory_ctrl.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c virtual_speed_sensor.c mcpa.c
  group plugins
    ../plugins/: dataAcq.c mc_config_ext.c Scheduler.c CRC16.c NVMemory.c param_defaults.c param_manager.c SineGenerator.c utils.c PositionControl.c PositionProfileGenerator.c positioncontrol.o positionprofilegenerator.o outAngleCalculate.c outanglecalculate.o
  group CANCommunication
    ../CANCommunication/: can_interface.c math_ops.c
  group user_application
    ../user_application/interface/: mc_app_hooks_Servo.c
    ../user_application/applications/: CurrentLoopBWTestApp.c EncoderAlignmentApp.c JogApp.c PositionCtrlApp.c SpeedloopBWTestApp.c BasicApp.c encoderalignmentapp.o MITControlApp.c HomingApp.c
  group Middlewares/ST/EEPROM_Emul/Core
    ../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/ST/EEPROM_Emul/Porting
    ../Middlewares/ST/EEPROM_Emul/Porting/STM32G4/: flash_interface.c
software components: CMSIS:CORE 6.1.1
